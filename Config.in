## Config.in
```kconfig
config BR2_PACKAGE_LIGHTS
       bool lights
       help
	driver lights controller
```
